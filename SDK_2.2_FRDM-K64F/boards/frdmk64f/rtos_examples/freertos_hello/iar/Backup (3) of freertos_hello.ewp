# IAR project Backup (3) of freertos_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM; _DLIB_PRINTF_SPECIFIER_FLOAT
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities; ../../../../../devices/MK64F12; G:\1.VNPT\2.Code\2.9 WQIV1.0\SDK_2.2_FRDM-K64F\boards\frdmk64f\rtos_examples\freertos_hello\Mylib; G:\1.VNPT\2.Code\2.9 WQIV1.0\SDK_2.2_FRDM-K64F\boards\frdmk64f\rtos_examples\freertos_hello\FlashDriver; G:\1.VNPT\2.Code\2.6 Backup code\2.6.4 WQIv1.0\SDK_2.2_FRDM-K64F\boards\frdmk64f\rtos_examples\freertos_hello\Mylib\mmcau_2.0.0; G:\1.VNPT\2.Code\2.9 WQIV1.0\SDK_2.2_FRDM-K64F\boards\frdmk64f\rtos_examples\freertos_hello\Mylib\jsmn-master
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: freertos_hello.srec
  ILINK.IlinkOutputFile: freertos_hello.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: G:\1.VNPT\2.Code\2.9 WQIV1.0\SDK_2.2_FRDM-K64F\boards\frdmk64f\rtos_examples\freertos_hello\Mylib\mmcau_2.0.0\asm-cm4-cm7\lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities; ../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group Mylib/FlashDriver
    ../FlashDriver/: slld.c slld.h slld_hal.c slld_hal.h slld_targetspecific.h
  group Mylib/Json
    ../Mylib/jsmn-master/: jsmn.c jsmn.h
    ../Mylib/jsmn-master/test/: testutil.h
  group Mylib/mmcau/mmcau_include
    ../Mylib/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group Mylib/mmcau/mmcau_source
    ../Mylib/mmcau_2.0.0/: fsl_mmcau.c
  group Mylib/task
    ../Mylib/: function_rtc.c function_rtc.h function_spi.c function_spi.h function_wqi.c function_wqi.h lowpower.c lowpower.h mymmcau.c mymmcau.h uart_task.c uart_task.h
  group source
    ../: FreeRTOSConfig.h main.c main.h
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
